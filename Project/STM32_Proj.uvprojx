# Keil uVision project STM32_Proj.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWLIB\inc;..\Libraries\CMSIS;..\Source\Main;..\Source\Dev;..\Source\RT-Thread\include;..\Source\RT-Thread\include\libc;..\Source\RT-Thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Main
    ../Source/Main/: main.c stm32f10x_conf.h stm32f10x_it.c config.h system.c board.c rtconfig.h Task.c Task.h Lock.c Lock.h SensorMQ.c SensorMQ.h
  group Dev
    ../Source/Dev/: SysTick.c Gpio.c USart.c ChipInfo.c ChipInfo.h Adc.c ADCTimer.c ADCTimer.h FinSHcmd.c
  group RT-Thread/Kernel
    ../Source/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/Port
    ../Source/RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group RT-Thread/FinSH
    ../Source/RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group Readme
    ../: Readme.txt
